# Keil uVision project rx.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rx
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\ZYRCRX;.\inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group 1
    ./: main.c delay.c i2c.c ssd1306.c nrf24l01.c spi.c
  group New Group
    ./inc/: defines.h delay.h i2c.h nrf24l01.h nrf24l01_defines.h spi.h uart.h ssd1306.h ssdfont.h
software components: CMSIS:CORE 5.0.1, Device:Startup 2.2.3
